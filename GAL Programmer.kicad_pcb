# Repository Mark-Clegg/GAL-Programmer

## KiCad design GAL Programmer.kicad_pcb

Parts:
C1, C2: 100nF; C_Disc_D3.8mm_W2.6mm_P2.50mm
C3: 10uF; CP_Radial_D5.0mm_P2.50mm
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: 4K7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: MT3608_Module-My_Symbols; MT3608Module
U2: GAL22V10B; DIP_Socket-24_W4.3_W5.08_W7.62_W10.16_W10.9_3M_224-5248-00-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
U3: GAL16V8; DIP_Socket-20_W4.3_W5.08_W7.62_W10.16_W10.9_3M_220-3342-00-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

Connections:
+5V: C1.1, C2.1, C3.1, P1.5, U1.1 (VIN+), U2.24, U3.20 (VCC)
/Edit: U1.3 (VOUT+), U2.2, U3.2 (I2)
/PV: P3.9, U2.3, U3.19 (IO1)
/RA0: P3.8, U2.4, U3.18 (IO2)
/RA1: P4.6, U2.5, U3.3 (I3)
/RA2: P4.5, U2.6, U3.4 (I4)
/RA3: P4.4, U2.7, U3.5 (I5)
/RA4: P4.3, U2.8, U3.6 (I6)
/RA5: P4.2, U2.9, U3.7 (I7)
/SCLK: P4.1, U2.10, U3.8 (I8)
/SDIN: P3.10, U2.11, U3.9 (I9)
/SDOUT: P3.6, U2.14, U3.12 (IO8)
/STROBE: P3.5, U2.13, U3.11 (I10/~OE~)
/VPP_EN: P3.7, R1.1, U1.5 (VPP_EN)
GND: C1.2, C2.2, C3.2, P1.6, P1.7, P3.4, R1.2, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, U1.2 (VIN-), U1.4 (VOUT-), U2.1, U2.12, U3.1 (I1/CLK), U3.10 (GND)
unnamed: R2.2, U2.23
unnamed: R3.2, U2.22
unnamed: R4.2, U2.21
unnamed: R5.2, U2.20
unnamed: R6.2, U2.19, U3.17 (I03)
unnamed: R7.2, U2.18, U3.16 (IO4)
unnamed: R8.2, U2.17, U3.15 (IO5)
unnamed: R9.2, U2.16, U3.14 (IO6)
unnamed: R10.2, U2.15, U3.13 (IO7)

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.

Board: 2 copper layers, 68.6 x 53.3 mm, 24 parts (0 on the bottom side), 24 nets.
